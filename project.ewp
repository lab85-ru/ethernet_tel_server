# IAR project project.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100xB ST STM32F100xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER=1; STM32F10X_MD_VL=1; IAR_ARM_CM3=1; DS18S20=1; ETH_ENC28J60=1; ETH_KSZ8851=0
  ICCARM.CCDiagSuppress: pa082
  ICCARM.CCIncludePath2: ; Libraries\CMSIS\CM3\CoreSupport; Libraries\CMSIS\CM3\DeviceSupport\STM32F10x; Libraries\STM32F10x_StdPeriph_Driver\inc; FreeRTOS\Source\include; FreeRTOS\Source\portable\IAR\ARM_CM3; uip; xprintf
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: 
  OBJCOPY.OOCOutputFile: EV_TWIN.hex
  ILINK.IlinkOutputFile: EV_TWIN.out
  ILINK.IlinkIcfFile: stm32.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; IAR_ARM_CM3
  ICCARM.CCIncludePath2: ; Libraries\CMSIS\CM3\CoreSupport; Libraries\CMSIS\CM3\DeviceSupport\STM32F10x; Libraries\STM32F10x_StdPeriph_Driver\inc; FreeRTOS\Source\include; FreeRTOS\Source\portable\IAR\ARM_CM3
  ICCARM.IccLang: 2
  ILINK.IlinkIcfFile: STM32F103VB.icf
  group (top)
    ./: adc.c adc.h board.c board.h consol.h enc28j60.c enc28j60.h env_config.c env_config.h git_commit.h heap_z.c heap_z.h http-strings.c http-strings.h httpd-cgi.c httpd-cgi.h httpd-fs.c httpd-fs.h httpd-fsdata.c httpd-fsdata.h httpd.c httpd.h i2c.c i2c.h inet.c inet.h init_hardware.c init_hardware.h mac.c mac.h main.c main.h network.c network.h printf_hal.h queue_buf.c queue_buf.h sys_timer.c sys_timer.h task_consol.c task_consol.h task_uip.c task_uip.h time_hal.c time_hal.h uptime.c uptime.h webserver.h
  group CMSIS
    Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    Libraries/CMSIS/CM3/DeviceSupport/STM32F10x/: system_stm32f10x.c
  group CMSIS/device
    Libraries/CMSIS/CM3/DeviceSupport/STM32F10x/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_hd_vl.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
  group FreeRTOS
    ./: FreeRTOSConfig.h
  group FreeRTOS/source
    FreeRTOS/Source/: croutine.c heap_2.c heap_3.c list.c queue.c tasks.c timers.c
    FreeRTOS/Source/portable/: port.c portasm.s
  group StdPeriph_Driver
    ./: stm32f10x_conf.h stm32f10x_it.c
  group StdPeriph_Driver/source
    Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group uip
    uip/: clock-arch.c clock-arch.h clock.h lc-addrlabels.h lc-switch.h lc.h psock.c psock.h pt.h timer.c timer.h uip-conf.h uip-fw.c uip-fw.h uip-neighbor.c uip-neighbor.h uip-split.c uip-split.h uip.c uip.h uip_arch.h uip_arp.c uip_arp.h uiplib.c uiplib.h uipopt.h
  group xprintf
    xprintf/: xprintf.c xprintf.h
